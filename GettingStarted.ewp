# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1764 NXP LPC1764
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_1768_SK
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SRAM
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC1768_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0_2\arm\inc\NXP
  OBJCOPY.OOCOutputFile: ANY815TS21V27SL.hex
  ILINK.IlinkIcfFile: config\LPC1768_Flash.icf
configuration Production (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: ANY815TS21V25JP
  ILINK.IlinkOutputFile: GettingStarted.out
  group (top)
    ./: cstartup_M.s globles.c main.c readme.txt version control.c
  group ANY815TS
    ./: ads1232.c audit.c calcmd.c caltransfer.c checkweigh.c com_tic_read.c display.c filter.c FIR.c flash.c gpio.c keypad.c keyscan.c menu.c motion.c peakhold.c printing.c prncode.c strings.c sys.c system_init.c tare.c ticcode.c ticketedit.c timedate.c units.c weight.c zero.c
  group LPC1764
    ./: irq.c rtc.c spi.c target.c timer.c uart.c wdt.c
